# IAR project Project.ewp, settings and files
configuration SolderStation (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x90
  General.GenHeapSize: 0x90
  ICCSTM8.CCDefines: STM8S003; USE_STM8_128_EVAL; DSS
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8S_EVAL\; ..\..\..\Utilities\STM8S_EVAL\STM8-128_EVAL\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SolderingStation_2 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S003; USE_STM8_128_EVAL; SOLDERING_VAR2
configuration HAKKO_A1321_MINI (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S003; USE_STM8_128_EVAL; DSS; SOLDERING_HAKKO_A1321_MINI
configuration HAKKO_A1321 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S003; USE_STM8_128_EVAL; DSS; SOLDERING_HAKKO_A1321
configuration DFS-90 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  ICCSTM8.CCDefines: STM8S103; USE_STM8_128_EVAL; DFS_90
  group SOLDERING_BSP
    ../../../Utilities/STM8S_EVAL/STM8-128_EVAL/: stm8_128_eval.c
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
  group User
    ../: 7-seg.c button.c main.c pid.c station.c stm8s_it.c thermo.c
